# Keil uVision project main.uvprojx, settings and files
target VTN (6210000::V6.21::ARMCLANG)
  device: STM32F401RCTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: main
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: main.c main.h encoder.c encoder.h usart.c usart.h var.c var.h hbridge.c hbridge.h sample_time.c sample_time.h adc.c adc.h calculation.c calculation.h
software components: CMSIS:CORE 6.0.0, Device:Startup 2.6.3
